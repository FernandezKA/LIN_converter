<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\J1708_converter\J1708_converter.ewp</path>
    </project>
    <batchBuild />
</workspace>
